# Keil uVision project kmdFoc.uvprojx, settings and files
target KmdFoc (6160000::V6.16::ARMCLANG)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20007FFF)IROM(0x08000000-0x0801FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: kmdFoc +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_STDPERIPH_DRIVER,GD32C10X,USE_USB_FS,HAL_GD32_LIB_USED,KMD_USB_USER
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32C10x\Include;..\Firmware\GD32C10x_standard_peripheral\Include;..\KmdFoc\Protocol;..\KmdFoc\Protocol\crc;..\KmdFoc\BspBoard\ENCODER;..\KmdFoc\BspBoard;..\Main;..\Firmware\GD32C10x_usbfs_library\device\core\Include;..\Firmware\GD32C10x_usbfs_library\driver\Include;..\Firmware\GD32C10x_usbfs_library\device\class\cdc\Include;..\Firmware\GD32C10x_usbfs_library\ustd\common;..\Firmware\GD32C10x_usbfs_library\ustd\class\cdc;..\KmdFoc\HalFocLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../Main/: main.c gd32c10x_it.c gd32c10x_hw.c
  group halFocEncoder
    ../KmdFoc/BspBoard/ENCODER/: bsp_mt6825.c bsp_ma730.c bsp_hall.c bsp_as5047.c
  group bspBoard
    ../KmdFoc/BspBoard/: bsp_can.c bsp_encoder.c bsp_gpio.c bsp_interface.c bsp_kmd.c bsp_svpwm.c bsp_systick.c bsp_uart.c bsp_flash.c bsp_device_id.c
  group Protocol
    ../KmdFoc/Protocol/: bsp_protocol.c
    ../KmdFoc/Protocol/crc/: bsp_crc8.c bsp_crc16.c
  group KmdFocLib
    ../KmdFoc/HalFocLib/: kmdFoc.lib
  group KmdFoc
    ../KmdFoc/HalFocLib/src/: hal_foc_interface.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group GD32C10x_Peripherals
    ../Firmware/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_can.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exti.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_fmc.c
  group USB_Drivers
    ../Firmware/GD32C10x_usbfs_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
  group USB_Device
    ../Firmware/GD32C10x_usbfs_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
  group USB_Class
    ../Firmware/GD32C10x_usbfs_library/device/class/cdc/Source/: cdc_acm_core.c
  group Startup
    ../Firmware/CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s
