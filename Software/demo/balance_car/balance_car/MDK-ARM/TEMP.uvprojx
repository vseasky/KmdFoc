# Keil uVision project TEMP.uvprojx, settings and files
target TEMP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: TEMP +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,STM32_THREAD_SAFE_STRATEGY=4
  c include: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F; ../Drivers/CMSIS/Include; ..\applications; ..\algorithm; ..\groundwork\bsp_adc; ..\groundwork\bsp_buzzer; ..\groundwork\bsp_dbus; ..\groundwork\bsp_delay; ..\groundwork\bsp_flash; ..\groundwork\bsp_led; ..\groundwork\bsp_rc; ..\groundwork\bsp_spi; ..\modules\bmi088; ..\modules\ist8310; ..\groundwork; ..\algorithm\Include; ..\algorithm; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ..\modules\protocol\crc; ..\modules\protocol; ..\groundwork\bsp_usb; ..\groundwork\bsp_protocol; ..\groundwork\bsp_can; ..\KmdFoc\inc; ..\algorithm\vSkyAhrs
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: main.c gpio.c freertos.c adc.c can.c dma.c i2c.c rng.c spi.c tim.c usart.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/CMSIS
    ./: startup_stm32f407xx.s
    ../Src/: system_stm32f4xx.c
  group groundwork
    ../groundwork/bsp_adc/: bsp_adc.c
    ../groundwork/bsp_buzzer/: bsp_buzzer.c
    ../groundwork/bsp_dbus/: bsp_dbus.c
    ../groundwork/bsp_delay/: bsp_delay.c
    ../groundwork/bsp_flash/: bsp_flash.c
    ../groundwork/bsp_led/: bsp_led.c
    ../groundwork/bsp_spi/: bsp_spi.c
    ../groundwork/bsp_rc/: bsp_rc.c
    ../groundwork/bsp_usb/: bsp_usb.c
    ../groundwork/bsp_protocol/: bsp_protocol_app.c
    ../groundwork/bsp_can/: bsp_can.c
  group applications
    ../applications/: imu_task.c led_task.c music_task.c key_task.c balance_car_task.c
  group protocol
    ../modules/protocol/: bsp_protocol.c
    ../modules/protocol/crc/: bsp_crc8.c bsp_crc16.c
  group algorithm
    ../algorithm/: user_lib.c pid.c arm_cortexM4lf_math.lib
    ../algorithm/vSkyAhrs/: MadgwickAHRS.c MahonyAHRS.c vSkyAhrs.c
  group ist8310
    ../modules/ist8310/: ist8310driver.c ist8310driver_middleware.c
  group bmi088
    ../modules/bmi088/: BMI088Middleware.c BMI088driver.c bsp_bmi088.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group KmdFoc
    ../KmdFoc/src/: hal_kmd_foc.c hal_kmd_interface.c
software components: CMSIS:CORE 5.6.0
